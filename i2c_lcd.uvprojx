# Keil uVision project i2c_lcd.uvprojx, settings and files
target i2c_lcd (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: timer 2 +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\src;..\..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c main.c i2c.c i2c.h i2c_lcd.c i2c_lcd.h
  group startup
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group lib
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c
software components: CMSIS:CORE 5.6.0
